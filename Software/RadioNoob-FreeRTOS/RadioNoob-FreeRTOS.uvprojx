# Keil uVision project RadioNoob-FreeRTOS.uvprojx, settings and files
target M483KIDAE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M483KIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: AT9C-FreeRTOS
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c include: ..\M480_BSP\CMSIS\Include;..\M480_BSP\StdDriver\inc;..\M480_BSP\Device\Nuvoton\M480\Include;..\M480_BSP\ThirdParty\FreeRTOS\Source\include;..\M480_BSP\ThirdParty\FreeRTOS\Demo\Common\include;..\M480_BSP\ThirdParty\FreeRTOS\Source\portable\MemMang;..\M480_BSP\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\M480_BSP\ThirdParty\FreeRTOS;..\AT9C-FreeRTOS;.\Application\Inc;.\Application\Src;.\Library\Inc;.\Library\Src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Application
    ./Application/Inc/: FreeRTOSConfig.h main.h
    ./Application/Src/: main.c
  group ThirdParty/FreeRTOS
    ../M480_BSP/ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../M480_BSP/ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../M480_BSP/ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group StdDriver
    ../M480_BSP/StdDriver/src/: clk.c sys.c uart.c bpwm.c dac.c eadc.c epwm.c gpio.c i2c.c pdma.c rtc.c sdh.c spi.c timer.c fmc.c qei.c
  group Library
    ./Library/Src/: common.c crsf.c delay.c eeprom.c memory_lcd.c inputs.c ring_buffer.c bfcFontMgr.c diskio.c ff.c ffsystem.c ffunicode.c sdcard.c sdh_control.c sound.c gui.c
    ./Library/Inc/: common.h crsf.h crsf_protocol.h delay.h eeprom.h inputs.h ring_buffer.h memory_lcd.h bfcfont.h bfcFontMgr.h cbuf.h diskio.h ff.h ffconf.h integer.h sdcard.h sdh_control.h sound.h tImage.h wav.h gui.h
  group Bitmaps
    ./Bitmaps/: antenna.c arrow_d.c arrow_l.c arrow_r.c battery.c battery_chrg.c KolamucLogo.c main_screen.c multirotor.c qr-code.c usb_logo.c user_logo.c value_box.c warning_screen.c
  group Font
    ./Fonts/: abeatbykai24.c Arcade36.c Consolas24B.c Consolas24h.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.00.001
