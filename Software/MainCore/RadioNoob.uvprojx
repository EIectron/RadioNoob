# Keil uVision project RadioNoob.uvprojx, settings and files
target M483 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M483KIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: RadiolinkAT9C
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c include: ..\M480_BSP\StdDriver\src;..\M480_BSP\StdDriver\inc;..\M480_BSP\CMSIS\Include;..\M480_BSP\Device\Nuvoton\M480\Include;.\Application\Inc;.\Application\Src;.\Library\Inc;.\Library\Src;.\Fonts;.\Bitmaps
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Application
    ./Application/Src/: main.c
    ./Application/Inc/: main.h
  group Library
    ./Library/Src/: bfcFontMgr.c common.c crsf.c delay.c diskio.c eeprom.c ff.c ffsystem.c ffunicode.c gui.c inputs.c memory_lcd.c ring_buffer.c sdcard.c sdh_control.c sound.c
    ./Library/Inc/: bfcfont.h bfcFontMgr.h cbuf.h crsf.h crsf_protocol.h common.h delay.h diskio.h eeprom.h ff.h ffconf.h gui.h inputs.h integer.h memory_lcd.h ring_buffer.h sdcard.h sdh_control.h sound.h tImage.h wav.h
  group Bitmaps
    ./Bitmaps/: usb_logo.c user_logo.c antenna.c battery.c battery_chrg.c main_screen.c multirotor.c warning_screen.c arrow_d.c arrow_l.c arrow_r.c value_box.c qr-code.c splash_screen.c
  group Fonts
    ./Fonts/: Consolas24h.c Arcade36.c abeatbykai24.c Consolas24B.c Arcade28.c
  group StdDriver
    ../M480_BSP/StdDriver/src/: bpwm.c clk.c dac.c eadc.c epwm.c fmc.c gpio.c hsusbd.c i2c.c pdma.c qei.c rtc.c spi.c sdh.c sys.c timer.c timer_pwm.c uart.c usbd.c wdt.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.00.001
